require nano.inc

BBCLASSEXTEND = "native"
BBVERSIONS = "1.0.[0-9] \
              1.2.[0-5] \
              2.0.[0-9] \
              2.1.4 2.1.8 2.1.9 2.1.10 \
              2.2.[0-3]"
DEFAULT_PREFERENCE_2.2.3 = "-1"

SRC_URI_2.0.9[md5sum] = "2be94dc43fb60fff4626a2401a977220"
SRC_URI_2.0.9[sha256sum] = "6d212385680d29dcda35dda7801da19c80182a8bc6bc6d5cf7533034c853d37f"
SRC_URI_2.0.7[md5sum] = "16187fed2bdefec6275ece6401ce4cd2"
SRC_URI_2.0.7[sha256sum] = "5dc783c412c4d1ff463c450d2a2f9e1ea53a43d9ba1dda92bbf5182f60db532f"
SRC_URI_2.2.3[md5sum] = "91918a484f54f94fedaebe00dc393a50"
SRC_URI_2.2.3[sha256sum] = "22f20ac3e17d8dcaff54389bdb417a4a0a099843ea7915225e48dedc474af4ee"