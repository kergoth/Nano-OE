require nano.inc
require checksums.inc

PR = "${INC_PR}.0"
BBVERSIONS = "2.0.[0-9] \
              2.1.[0-11] \
              2.2.[0-3]"
